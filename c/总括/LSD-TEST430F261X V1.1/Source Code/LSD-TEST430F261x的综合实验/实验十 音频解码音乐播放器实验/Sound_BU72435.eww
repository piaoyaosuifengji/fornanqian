<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BU72435.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\&#x5B9e;&#x9A8C;&#x516D; &#x8BeD;&#x97F3;&#x5904;&#x7406;&#x5B9e;&#x9A8C;\Sound Test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


