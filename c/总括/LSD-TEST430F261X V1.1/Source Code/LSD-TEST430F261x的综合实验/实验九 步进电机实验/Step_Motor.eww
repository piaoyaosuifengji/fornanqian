<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\MSP430F261x&#x57FA;&#x672C;&#x6A21;&#x5757;&#x5B9e;&#x9A8C;\C&#x8BeD;&#x8A00;&#x4ee3;&#x7801;&#x5B9e;&#x9A8C;\&#x5B9e;&#x9A8C;&#x4e8C; DCO&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\&#x57FA;&#x4e8e;&#x7247;&#x5916;&#x7535;&#x963B;&#x8C03;&#x8282;&#x7684;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\DCO_Rosc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\MSP430F261x&#x57FA;&#x672C;&#x6A21;&#x5757;&#x5B9e;&#x9A8C;\C&#x8BeD;&#x8A00;&#x4ee3;&#x7801;&#x5B9e;&#x9A8C;\&#x5B9e;&#x9A8C;&#x4e00; &#x7AeF;&#x53e3;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\&#x4e2D;&#x65AD;&#x7AeF;&#x53e3;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\ISR_Port.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\MSP430F261x&#x57FA;&#x672C;&#x6A21;&#x5757;&#x5B9e;&#x9A8C;\&#x6C47;&#x7F16;&#x4ee3;&#x7801;&#x5B9e;&#x9A8C;\&#x5B9e;&#x9A8C;&#x4e00; &#x7AeF;&#x53e3;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\&#x4e2D;&#x65AD;&#x7AeF;&#x53e3;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\ISR_Port.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\&#x5B9e;&#x9A8C;&#x4e8C; &#x6570;&#x7801;&#x7BA1;&#x663e;&#x793A;&#x5B9e;&#x9A8C;\Led_Display.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\MSP430F261x&#x57FA;&#x672C;&#x6A21;&#x5757;&#x5B9e;&#x9A8C;\C&#x8BeD;&#x8A00;&#x4ee3;&#x7801;&#x5B9e;&#x9A8C;\&#x5B9e;&#x9A8C;&#x4e00; &#x7AeF;&#x53e3;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\&#x8DD1;&#x9A6C;&#x706F;&#x5B9e;&#x9A8C;\Leds.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\&#x5B9e;&#x9A8C;&#x56DB; &#x5355;&#x8272;LCD&#x663e;&#x793A;&#x5B9e;&#x9A8C;\LM240160.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\MSP430F261x&#x57FA;&#x672C;&#x6A21;&#x5757;&#x5B9e;&#x9A8C;\C&#x8BeD;&#x8A00;&#x4ee3;&#x7801;&#x5B9e;&#x9A8C;\&#x5B9e;&#x9A8C;&#x4e00; &#x7AeF;&#x53e3;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\PA&#x7AeF;&#x53e3;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\PA_Port.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\MSP430F261x&#x57FA;&#x672C;&#x6A21;&#x5757;&#x5B9e;&#x9A8C;\&#x6C47;&#x7F16;&#x4ee3;&#x7801;&#x5B9e;&#x9A8C;\&#x5B9e;&#x9A8C;&#x4e00; &#x7AeF;&#x53e3;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\PA&#x7AeF;&#x53e3;&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\PA_Port.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\&#x5B9e;&#x9A8C;&#x4e00; &#x6BB5;&#x5F0F;LCD&#x5B9e;&#x9A8C;\Segment_LCD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\&#x5B9e;&#x9A8C;&#x516D; &#x8BeD;&#x97F3;&#x5904;&#x7406;&#x5B9e;&#x9A8C;\Sound Test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


