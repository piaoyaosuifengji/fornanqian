<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\WDT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\C&#x8BeD;&#x8A00;&#x4ee3;&#x7801;&#x5B9e;&#x9A8C;\&#x5B9e;&#x9A8C;&#x516D; WDT&#x64CD;&#x4F5C;&#x5B9e;&#x9A8C;\WDT.ewp</path>
  </project>
  <batchBuild/>
</workspace>


