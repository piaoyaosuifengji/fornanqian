# IAR project CLK.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2619 MSP430F2619
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: msp430F2619_clk.s43
