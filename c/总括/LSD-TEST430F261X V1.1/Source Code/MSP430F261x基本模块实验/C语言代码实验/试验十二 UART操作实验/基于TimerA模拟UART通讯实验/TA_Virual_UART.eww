<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TA_Virual_UART.ewp</path>
  </project>
  <batchBuild/>
</workspace>


