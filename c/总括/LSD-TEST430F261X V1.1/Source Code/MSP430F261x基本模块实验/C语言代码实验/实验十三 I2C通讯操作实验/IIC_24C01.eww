<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\24C01.ewp</path>
  </project>
  <batchBuild/>
</workspace>


