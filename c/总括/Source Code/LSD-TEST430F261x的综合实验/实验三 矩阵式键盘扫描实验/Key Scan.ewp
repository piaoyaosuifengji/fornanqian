# IAR project Key Scan.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2619 MSP430F2619
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.newCCIncludePaths: Source Code\LCD\; Source Code\Key Code\
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group (top)
    Source Code/LCD/: Disp_Ch.c Font_Storage.c LM240160GCW.c
    Source Code/Key Scan/: Init_MSP430.c Key Scan.c
